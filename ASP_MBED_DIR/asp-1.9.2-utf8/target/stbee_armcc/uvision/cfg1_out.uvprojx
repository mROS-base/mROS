# Keil uVision project cfg1_out.uvprojx, settings and files
target cfg1_out (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: cfg1_out
  BeforeMake: ../../../cfg/cfg/cfg --pass 1 --kernel asp -I. -I../../../ -I../../../include -I../../../arch -I../..  -I../../../target/stbee_armcc -I../../../arch/arm_m_armcc/stm32f -I../../../arch/arm_m_gcc/stm32f -I../../../arch/arm_m_armcc/common -I../../../arch/arm_m_gcc/common -I../../../target/stbee_gcc --api-table ../../../kernel/kernel_api.csv --cfg1-def-table ../../../kernel/kernel_def.csv  --cfg1-def-table ../../../arch/arm_m_gcc/common/core_def.csv ../../../sample/sample1.cfg
  AfterMake: fromelf --m32combined cfg1_out.axf --output=cfg1_out.srec
  AfterMake: ../../../cfg/cfg/cfg --pass 2 --kernel asp -I. -I../../../ -I../../../include -I../../../arch -I../..  -I../../../target/stbee_armcc -I../../../arch/arm_m_armcc/stm32f -I../../../arch/arm_m_gcc/stm32f -I../../../arch/arm_m_armcc/common -I../../../arch/arm_m_gcc/common -I../../../target/stbee_gcc -T ../../../target/stbee_armcc/target.tf --api-table ../../../kernel/kernel_api.csv --cfg1-def-table ../../../kernel/kernel_def.csv --cfg1-def-table ../../../arch/arm_m_gcc/common/core_def.csv ../../../sample/sample1.cfg
  c flags: Optim=4
  c misc: --diag_style=gnu --gnu --bss_threshold=0
  c include: .;../../../;../../../include;../../../arch/;../../../arch/armcc;../..;../../../target/stbee_armcc;../../../arch/arm_m_armcc/stm32f;../../../arch/arm_m_gcc/stm32f;../../../arch/arm_m_armcc/common;../../../arch/arm_m_gcc/common;../../../target/stbee_gcc;../../../kernel;../../../sample/
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\target\stbee_armcc\stbee.scat
  link misc: --diag_style=gnu --datacompressor=off --symdefs=cfg1_out.syms --no_remove --entry=_start
  group cfg
    ../../../sample/: sample1.cfg
  group src
    ./: cfg1_out.c
    ../../../arch/arm_m_armcc/common/: start.sx
software components: CMSIS:CORE 4.1.0
