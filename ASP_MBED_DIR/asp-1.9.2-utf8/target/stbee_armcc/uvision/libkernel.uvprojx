# Keil uVision project libkernel.uvprojx, settings and files
target libkernel (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: libkernel (library)
  BeforeMake: ../../../cfg/cfg/cfg --pass 3 --kernel asp -I. -I../../../ -I../../../include -I../../../arch -I../..  -I../../../target/stbee_armcc -I../../../arch/arm_m_armcc/stm32f -I../../../arch/arm_m_gcc/stm32f -I../../../arch/arm_m_gcc/stm32f/cmsis -I../../../arch/arm_m_armcc/common -I../../../arch/arm_m_gcc/common -I../../../target/stbee_gcc --rom-image cfg1_out.srec --symbol-table cfg1_out.syms -T ../../../arch/arm_m_gcc/stm32f/chip_offset.tf --api-table ../../../kernel/kernel_api.csv --cfg1-def-table ../../../kernel/kernel_def.csv  --cfg1-def-table ../../../arch/arm_m_gcc/common/core_def.csv ../../../sample/sample1.cfg
  c flags: Optim=4
  c misc: --diag_style=gnu --gnu --bss_threshold=0 -DALLFUNC
  c include: .;../../../;../../../include;../../../arch/;../../../arch/armcc;../.. ;../../../target/stbee_armcc;../../../arch/arm_m_armcc/stm32f;../../../arch/arm_m_gcc/stm32f;../../../arch/arm_m_armcc/common;../../../arch/arm_m_gcc/common;../../../target/stbee_gcc;../../../kernel
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group kernel
    ../../../kernel/: alarm.c cyclic.c dataqueue.c eventflag.c exception.c interrupt.c mailbox.c mempfix.c pridataq.c semaphore.c startup.c sys_manage.c task.c task_except.c task_manage.c task_refer.c task_sync.c time_event.c time_manage.c wait.c
  group target
    ../../../target/stbee_gcc/: target_config.c
  group chip
    ../../../arch/arm_m_gcc/stm32f/: chip_config.c
  group arch
    ../../../arch/arm_m_armcc/common/: core_support.sx
    ../../../arch/arm_m_gcc/common/: core_config.c core_timer.c
software components: CMSIS:CORE 4.1.0
