# Keil uVision project asp.uvprojx, settings and files
target asp (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: asp
  AfterMake: fromelf --m32combined asp.axf --output=asp.srec
  AfterMake: ../../../cfg/cfg/cfg --pass 3 --kernel asp -I. -I../../../ -I../../../include -I../../../arch -I../..  -I../../../target/stbee_armcc -I../../../arch/arm_m_armcc/stm32f -I../../../arch/arm_m_gcc/stm32f -I../../../arch/arm_m_gcc/stm32f/cmsis -I../../../arch/arm_m_armcc/common -I../../../arch/arm_m_gcc/common -I../../../target/stbee_gcc --rom-image asp.srec --symbol-table asp.syms -T ../../../target/stbee_armcc/target_check.tf --api-table ../../../kernel/kernel_api.csv --cfg1-def-table ../../../kernel/kernel_def.csv  --cfg1-def-table ../../../arch/arm_m_gcc/common/core_def.csv ../../../sample/sample1.cfg
  c flags: Optim=4
  c misc: --diag_style=gnu --gnu --bss_threshold=0
  c include: .;../../../;../../../include;../../../arch;../../../arch/armcc;../.. ;../../../target/stbee_armcc;../../../arch/arm_m_armcc/stm32f;../../../arch/arm_m_gcc/stm32f;../../../arch/arm_m_gcc/stm32f/cmsis;../../../arch/arm_m_armcc/common;../../../arch/arm_m_gcc/common;../../../target/stbee_gcc;../../../kernel;../../../sample
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\stbee.scat
  link misc: --diag_style=gnu --datacompressor=off  --no_remove --entry=_start  --symdefs=asp.syms
  group app
    ../../../sample/: sample1.c
  group syssvc
    ../../../syssvc/: banner.c logtask.c serial.c syslog.c
    ../../../library/: log_output.c strerror.c t_perror.c vasyslog.c
    ../../../arch/arm_m_gcc/stm32f/: usart.c
  group kernel
    ./: kernel_cfg.c libkernel.lib
    ../../../arch/arm_m_armcc/common/: start.sx
software components: CMSIS:CORE 4.1.0
